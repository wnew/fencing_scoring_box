# Repository wnew/fencing_scoring_box

File README.md:

# Arduino Fencing Scoring Apparatus

## Description

Fencing Scoring Machine/Box/Apparatus code for the arduino platform.
This project is an arduino based fencing scoring machine. It supports all 3
weaspons, foil, epee and sabre.

Detailed assembly instructions are on instructables: 
https://www.instructables.com/id/Arduino-Fencing-Scoring-Apparatus/

Email me if you have any questions: wesnew(at)gmail(dot)com

## Directory Structure

**Firmware**: the code that runs on the arduino including scoring boxes and test
sketches.

**Hardware**: the circuit designs around the arduino showing how to connect up the
lights and body wires.

**Software**: python code which communicates over the serial interface with the
arduino to allow displaying of lights on a laptop or PC screen. This is a simple 
test and further development is required.

**Notes and research**  Pretty self explanitory

## Hardware Requirements

 - 1 Arduino Uno or Nano (5v/16MHz)
 - 10 Resistors, 4 220R for LEDs, 6 1K for pullups/pulldowns
 - 4 LEDs, 1 green, 1 red and 2 yellow/white

## Percentage Complete

Foil       100 %

Epee       100 %

Sabre       90 % - Just missing whipover functionality

## TODOs

 - Implement and test whipover for sabre

## Testing

 - Tested with an oscilloscope and all timings look great.

## Extra features to add

 - Add some kind of screen
 - Serial to USB interface to use a laptop as the lights, timing and scoring,
   similar to the VSM. This is already implemented on the device, just write
   some code for the PC side.

## KiCad design designs/wired_scoring_box/hardware/fencing_scoring_box_led_matrix/fencing_scoring_box_led_matrix.kicad_pcb

File designs/wired_scoring_box/hardware/fencing_scoring_box_led_matrix/readme:

Readme

V1.2 Updates:
Reduced size of mounting holes and banana sockets
Rounded corners and silkscreen boarder

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
U1, U2, U3, U4: WS2812b_4x4_matrix

Connections:
5V: J2.1, J2.2, U1.3 (+5V), U1.6 (+5V), U2.3 (+5V), U2.6 (+5V), U3.3 (+5V), U3.6 (+5V), U4.3 (+5V), U4.6 (+5V)
GND: H1.1, H2.1, H3.1, H4.1, J2.4, J2.5, U1.1 (GND), U1.4 (GND), U1.5 (GND), U1.8 (GND), U2.1 (GND), U2.4 (GND), U2.5 (GND), U2.8 (GND), U3.1 (GND), U3.4 (GND), U3.5 (GND), U3.8 (GND), U4.1 (GND), U4.4 (GND), U4.5 (GND), U4.8 (GND)
unnamed: J2.3, U1.2 (In)
unnamed: U1.7 (Output), U2.2 (In)
unnamed: U2.7 (Output), U3.2 (In)
unnamed: U3.7 (Output), U4.2 (In)

Board: 2 copper layers, 100.0 x 70.0 mm, 9 parts (1 on the bottom side), 6 nets.

## KiCad design designs/wired_scoring_box/hardware/fencing_scoring_box/fencing_scoring_box.kicad_pcb

Board: 2 copper layers, 100.0 x 70.0 mm, 37 parts (0 on the bottom side), 26 nets.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C2: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6: D_Zen; diode_THT_and_1206
H1: Piste Connetor; fencing_piste_conn
H2, H3, H4, H5: Mounting Hole; MountingHole_3.2mm_M3_DIN965_Pad
J1: LED_Matrix; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J4: Red LEDs; PinHeader_1x04_P2.54mm_Vertical
J7: Mode_LEDs; PinHeader_1x04_P2.54mm_Vertical
J9, J11: Fencing_conn
J10: Grn LEDs; PinHeader_1x04_P2.54mm_Vertical
J13: Grn; PinHeader_1x03_P2.54mm_Vertical
J14: Red; PinHeader_1x03_P2.54mm_Vertical
R3, R5, R6, R10, R11, R12: 1k; resistor_THT_and_0805
R19, R20, R21, R22, R23, R24: 100; resistor_THT_and_0805
SW1: Weapon Select; SW_PUSH_6mm_H4.3mm

Connections:
GND: A1.4 (GND), A1.29 (GND), BZ1.1 (-), C2.2, C3.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), H1.1, H2.1, H3.1, H4.1, H5.1, J1.4, J1.5, J3.1, J4.4, J7.4, J10.1, R3.1, R5.1, R10.1, R11.1, SW1.2
Grn_A: A1.19 (A0), R23.1
Grn_A_out: D5.1 (K), J11.1, J13.1, R11.2, R23.2
Grn_B: A1.21 (A2), R22.1
Grn_B_out: D6.1 (K), J11.2, J13.2, R12.2, R22.2
Grn_C: A1.23 (A4), R24.1
Grn_C_out: D4.1 (K), J11.3, J13.3, R10.2, R24.2
Grn_OffT_LED: A1.11 (D8), J10.3
Grn_OnT_LED: A1.10 (D7), J10.4
Grn_Short_LED: A1.12 (D9), J10.2
Red_A: A1.20 (A1), R19.1
Red_A_out: D2.1 (K), J9.1, J14.1, R5.2, R19.2
Red_B: A1.22 (A3), R21.1
Red_B_out: D3.1 (K), J9.2, J14.2, R6.2, R21.2
Red_C: A1.24 (A5), R20.1
Red_C_out: D1.1 (K), J9.3, J14.3, R3.2, R20.2
Red_OffT_LED: A1.14 (D11), J4.2
Red_OnT_LED: A1.15 (D12), J4.1
Red_Short_LED: A1.13 (D10), J4.3
VCC: A1.27 (+5V), C2.1, C3.1, J1.1, J1.2, R6.1, R12.1
button: A1.5 (D2), SW1.1
buzzer: A1.6 (D3), BZ1.2 (+)
display1: A1.16 (D13), J1.3
mode_led_epee: A1.7 (D4), J7.1
mode_led_foil: A1.8 (D5), J7.2
mode_led_sabre: A1.9 (D6), J7.3

## Commit log

2012-10-30 updates to foil and epee boxes
2012-10-30 updates to the foil and epee boxes
2012-10-31 removing empty files
2012-10-31 updating comments and adding sabre skeleton code
    at this stage all code is untested
2012-11-15 Updates to the epeebox code
    Fixing a bug or 2, but there is still an issue with a double hit
    where if the hits are a certain time apart, one light will go on
    for the 3.5s and then the other will come on only after the first
    has gone off. This needs to be sorted out.
2012-11-16 Updates to epeebox and indentation fixes
    Foilbox indentation fixed
    Epeebox bug fix
    Sabre box hasnt been updated as it still needs to be written, at the mo it is
    just a copy of the foilbox
2012-11-16 adding design files and sw_testing files
2012-11-17 solve bug with epee!!
    added in the check for lame voltage to prevent a touch on the gaurd being
    signalled as a hit.
    epeebox now fully tested on a bread board and now ready for connecting upto
    real weapons.
2012-11-17 lame pins needed to be swapped around
    ie FencerA hits FencerB's lame
2012-11-17 foil and epee working perfectly, breadboard tests
2012-11-17 changing the file extentions to .ino
    The new Arduino IDE uses a new file extention (pde -> ino)
2012-11-18 major changes to the timing test sktech
2012-11-22 adding the foil tests
2012-11-23 updating epee and foil
    They now take into account that the pins can be at 0v 2.5v or 5v when cheking
    fot a hit
2012-11-24 Updates to the timing tests
    More to come
2012-11-26 Adding serial software for laptop box
    Started on the software serial connection to let a box display hits
    on a laptop/pc screen
    Also added some simple serial test firmware
2012-11-26 restructuring the software and firmware
2012-11-26 moving old files
2012-11-26 admin
2012-11-26 Adding the circuit external to the arduino
2012-11-27 updates to timing tests
2012-11-28 updates to the serial and gui software
    basic lights are now displayed depending on serial messages
    updated foil and epee firmware to send single characters over the serial
    connection
2012-11-28 few small changes
    Adding the first working sabre firmware, whipover not yet implemented
2012-11-28 changes to the display app
2012-12-01 Adding get timing methods to test image
    Added methods to get the foil and epee lockout and depress times of a box
    They might need to have a finer resolution then milliseconds, but Ill try
    microseconds if it is needed.
2012-12-03 putting the weapons together into one sketch
    also updating the timing tests to do more timing checks
2012-12-03 adding timing parameters to all weapons box
2012-12-04 updating timings for weapons
    and getting the all weapons design to compile, now just to test it
2012-12-04 adding the timing regulations to the design folder
2012-12-13 Adding the lcd menu controller sketch
2012-12-13 Mainly updates to the test_box, plus others
2012-12-14 Adding display text to the test_box stetch
2012-12-18 adding the buzzer to the foil and epee boxes
    Also updating the test_box
2013-02-19 adding firmware for the IR sensor
    Still to be integrated into the main code though
2013-02-19 adding IR sensor to the firmware
2013-02-20 updating sketch formatting
    removed trailing white spaces
    updated comments on the all weapon box sketch
2013-02-20 Update README.md
    update
2013-02-21 updates to the all weapon box
    mostly asthetics of the code
2013-02-21 adding the buzzer and mode led pins
    Added the buzzer pin and the corresponding logic
    Added the mode led pins and the corresponding logic
2013-02-22 Updating pins on the all weapons box
    There was overlap as interrupt pins 0/1 map to digital pins 2/3
2013-02-24 updating the testing box fw
    now inlcudes both the serial and lcd version
    started implementing ver2 that is more generic and can be used on any box
2013-02-25 Completed the generic test box implementation
    Still needs to be tested
2013-02-26 updates to test box v2
    foil has been tested and works well
2013-02-26 tweaking allweapon box
    the correct mode led comes on at start up
    reordered the pins to make more logical sense
2013-05-28 updating directory structure
2013-05-28 removing old sketches
2013-08-19 updates to the external circuits
2013-08-19 adding sw and images
2014-07-18 a few small changes
2014-07-18 changes to the allweapons box
2014-07-21 mostly changes to the ACD config
    Also updates to the readmes and hw files
2014-07-21 Updates to circuit and tables
2014-07-22 attempting to use readme.md syntax
2014-07-22 seems like it should be README.md
2014-07-22 Yes another readme commit
2014-08-06 Reimpl of the scoring boxes
    The way in which the boxes figure out hits has been redone.
    It provides more stability and a better method to check scoring.
    This will be incorporated into the allweaponsbox soon
2015-01-06 Made circuit clearer
2015-01-07 lots of small changes
    1. added support for internal pull up resistors
    2. added some test box sketches, untested at the moment
    3. updated the circuit diagram to make it clearer
2015-01-07 Fixing bug with analog pins
    Now we set the analog pins as inputs not the digital ones.
2015-01-08 Mods to dir structure and readme
2015-01-08 cleaning up the allweapon box code
2015-01-08 fix to all weapon box
2015-01-09 Update circuit
2015-01-15 Moving some file around
    also some asthetic updates
2015-01-15 moving test_box
2015-08-26 A number of updates
    Fix to the allweaponbox
2015-08-27 A fully simulated epee box
2015-08-28 rearchitecture of the foilbox
    Foil box simulates perfectly. Just havent tested the guard/lame bug
    Also updated the epeebox
2015-08-28 rearch of sabre box
    also some cleaned up foil and epee boxed
2015-09-06 Major bug fix to foil
    Plus some other updates
2015-09-07 minor changes to the boxes
2015-09-08 Rename readme to readme.md
2015-11-07 changing 20k resistors to 1k
    It turns out that the long wires used in fencing combined with 20k pull up/down
    resistors create an RC filter. It is better to use 1k resistors instead.
2016-12-05 Updating the mode button
2017-01-11 minor updates
    updated pullup resistor values in the readme
    clarified the modePin interrupt (0/2) in the allweapon box
2017-03-06 Create license
2017-03-14 adding BOOK 3. MATERIAL RULES
2018-08-05 Updated to new sabre timings
    Back in 2016, FIE introduced new timings for sabre, taking the lockout time from 120ms to 170ms
2024-01-11 Update circuit
    Changing pin 0 to pin 2
2024-01-15 Fix to mode LEDs
    The mode LEDs were not being set when the mode button was pushed. This has now been fixed.
2024-06-18 Add files via upload
    Adding FIE Material Rules document
2024-06-18 Update circuit
    Fixed the expected ADC voltages
2024-06-20 Updating some notes and docs and minor errors
2024-06-20 updating voltage tables
2024-06-20 updates to the timing tables
2024-06-20 Added support for the neopixel shield
    Also adding sketches to test features such as ADC and button interrupts
2024-06-20 Adding testing machine specs pdf
2024-07-05 Support for PCB rev4
    Updated to the all weapons box:
    Support for multiple led matrices
    Improved the button debounce and responsiveness
    Added tone for the buzzer
    Support for turning off buzzer
    Support for the Pro Micro, need to provide options to use Uno or Promicro though.
2024-07-17 Updates to the allweaponbox
    Inclues the following:
    Fix to the buzzer to set the pin high rather than setting a tone
    Fix to the matrix leds to prevent them from being "turned on" multiple times for one hit
    Swapped the lights around, now green is left and red ir right
    Changed the fencer input pins around to work with the new PCB that is on the way
    Renamed some variables and pins to make the code clearer
2024-07-17 Cleaning up old files and updating readmes
2024-07-18 Adding kicad hardware designs
    - Design for the main box PCN
    - Design for the LED matrix PCB that mounts on the main box
    - removed temp design file which is not needed
2024-07-18 Adding updated circuit diagram
    A lot of people have asked for this, so here it is. I hope this is clearer than the text document.
    Ill be updating the instructable with this circuit diagram shortly.
2024-07-18 updates to the PCB layout
    removed jumper references
    removed header pin 3d models
2024-07-23 Pin changes to arduino code and renaming pcb design
    Changed the pins to be compatibe with the new PCB design for an arduino
    nano
2024-07-23 Restructuring the repo and adding epee buzz box
    The repo is restructured to accomodate multiple designs including the epee buzz
    box and ultimately the wireless scoring box
    Added in the epee buz box design files
2024-07-23 Minor changes to the circuit and the code comments
2024-07-23 Adding LED to the schematic
2024-08-01 PCB Version 5 firmware and pcb updates
    1. Updated the firmware to support only one matrix of 64 LEDs
    2. Updated the PCB design error found when assembling the PCB
    - Turns out the Arduino Nano A6 and A7 pins cant be used as digital
    and now the display runs off pin 13 rather than pin A6
    - Corrected some pin names on the silkscreen
    Still need to increase the hole size for the button to protrude through the
2024-08-02 Adding initial support for short circuit indicators
    The SC lights now work for all SCs except A-C because they are both pulled
    to ground with a 1k resistor and would read the same voltage regardless.
    Short circuits are currently check for every 2 seconds.
    Must come up with a way to work around this.
2024-08-02 Finalising support for short circuit.
    All short circuit seems to be working well now.
2024-08-05 Updates to the short circuit logic
    Parameterised the time between SC checks
    Added code to check the time a SC check takes. (Will remove this later, when more
    testing is completed)
2024-08-07 Fixes after testing Sabre with real fencers
    My understanding of Sabre was flawed, the B and C wires are actually connected
    in the weapon which meant that the scoring was not working correctly as we
    expected a higher ADC value. These have been updated and now Sabre should work
    correctly. Now just to implement whipover and then Sabre is complete.
2024-08-08 Updates to the matrix display board
    Updated the ws2812b 4x4 matrix footprint and symbol
    Increased the size of the buzzer and button holes
2024-08-18 Update adc_values
2024-08-19 Fixed for Sabre and short circuit logic
    1. Sabre was not working properly this has been fixed and sabre is working
    although whipover is still outstanding
    2. The documentation with the tables for the acd values was updated to
    accomodate the issue with foil where a guard against your own lame prevents
    a touch from being scored. This issue still needs to be addresses.
2024-08-26 Updating Sabre to check for B-C open circuit
    In Sabre if B-C are open circuit the off-target lights should turn on
    This makes it similar to foil, but the off-target lights show a issue
    with the weapon rather than an off-target hit. Not sure why the short
    circuit lights are not used for this.
2024-08-26 Update allweaponbox.ino
    Left some code in the sabre function on the last change. Cleaned it up.
2024-08-27 Adding 3D printing files for the edging of the box
    Added stl and image of the design
